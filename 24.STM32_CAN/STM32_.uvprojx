# Keil uVision project STM32_.uvprojx, settings and files
target STM32_ (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32_ +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\User;.\FWLib\inc;.\Core;.\Driver;.\Interface
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c system_stm32f4xx.h main.c
  group Core
    ./Core/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f40_41xxx.s
  group FWLib
    ./FWLib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Driver
    ./Driver/: DELAY.c DELAY.h LED.c LED.h KEY.c KEY.h KEY_EXTI.c KEY_EXTI.h USART.c USART.h I2C_Hardware.c I2C_Hardware.h TIM6.c TIM6.h TIM14.c TIM14.h TIM1.c TIM1.h TIM8.c TIM8.h TIM4.c TIM4.h DMA_ROM2RAM.c DMA_ROM2RAM.h DMA_UART.c DMA_UART.h ADC.c ADC.h ADC_DMA.c ADC_DMA.h SPI_SOFT.c SPI_SOFT.h SPI_HARDWARE.c SPI_HARDWARE.h FSMC_SRAM_s.c FSMC_SRAM_s.h FSMC_LCD.c FSMC_LCD.h LCD.c LCD.h lcdfont.c lcdfont.h CAN.c CAN.h
  group Interface
    ./Interface/: flash_s.c flash_s.h m24c02_h.c m24c02_h.h flash_h.c flash_h.h
